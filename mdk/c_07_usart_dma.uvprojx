# Keil uVision project c_07_usart_dma.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: ATSAME70Q21 Atmel
  pack: Keil.SAM-E_DFP.1.0.0
  cpu: IROM(0x00400000,0x00200000) IRAM(0x20400000,0x00060000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: c_07_usart_dma
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c include: ..\include
  memory RVCT4: ROM 0x400000 size 0x200000
  memory RVCT9: RAM 0x20400000 size 0x60000
  group Source Group 1
    ../source/: main.c board.c delay.c usart_same70.c watchdogs.c os_usart_same70.c os_serial_stdio.c safe_stdlib.c dma_same70.c
software components: CMSIS:CORE 4.1.0, CMSIS:RTOS:Keil RTX 4.78.0, Device:Startup 1.0.0
